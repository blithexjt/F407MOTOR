# Keil uVision project MOTOR.uvprojx, settings and files
target MOTOR (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MOTOR +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\HARDWARE\DRV8889;..\HARDWARE\MOTOR;..\HARDWARE\MYSPI;..\HARDWARE\TIMER;..\HARDWARE\TMC260;C:\Keil_v5\ARM\ARMCC\include;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\UCOMMAND;..\HARDWARE\QUEUE;..\HARDWARE\SEM;..\HARDWARE\FORCE;..\SYSTEM\MUSART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/DRV8889/: drv8889.c
    ../HARDWARE/MYSPI/: spi.c
    ../HARDWARE/UCOMMAND/: ucommand.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/QUEUE/: queue.c
    ../HARDWARE/SEM/: sem.c
    ../HARDWARE/FORCE/: force.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/MUSART/: musart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_can.c
  group README
    ../: readme.txt
